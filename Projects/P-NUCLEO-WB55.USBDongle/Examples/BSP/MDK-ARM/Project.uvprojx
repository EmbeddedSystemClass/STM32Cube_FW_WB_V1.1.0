# Keil uVision project Project.uvprojx, settings and files
target P-NUCLEO-WB55.USBDongle (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx.0.0.7
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2002FFFF) IRAM_SHARED(0x20030000-0x20037FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32WB55xx,USE_STM32WBXX_USB_DONGLE,USE_HAL_DRIVER,CORE_CM4
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.USBDongle
    ../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle/: stm32wbxx_usb_dongle.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c
  group Example/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Example/User
    ../Src/: main.c stm32wbxx_it.c
software components: CMSIS:CORE 4.3.0
