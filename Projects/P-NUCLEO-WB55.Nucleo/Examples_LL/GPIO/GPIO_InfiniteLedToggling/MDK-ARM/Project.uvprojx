# Keil uVision project Project.uvprojx, settings and files
target STM32WB55RG_Nucleo_GPIO_InfiniteLedToggling (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx.0.0.7
  cpu: IRAM(0x20000000,0x40000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32WB55xx,CORE_CM4
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
  group Drivers/STM32WBxx_LL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_ll_utils.c stm32wbxx_ll_gpio.c
  group Example/User
    ../Src/: main.c stm32wbxx_it.c
  group Example/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
software components: CMSIS:CORE 5.0.1
