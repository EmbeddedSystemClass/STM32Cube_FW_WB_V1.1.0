# IAR project ble_beacon.ewp, settings and files
configuration BLE_Beacon (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STM32WBXX_NUCLEO; USE_HAL_DRIVER; STM32WB55xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_WPAN/App; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../../../../../../Middlewares/ST/STM32_WPAN/utilities; ../../../../../../Middlewares/ST/STM32_WPAN/ble; ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/Inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/Inc/core; ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/Src/core; ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/Src/blesvc; ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/Inc/blesvc; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Beacon.hex
  ILINK.IlinkOutputFile: BLE_Beacon.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User
    ../Core/Src/: app_entry.c main.c stm32wbxx_it.c stm32wbxx_hal_msp.c
    ../STM32_WPAN/App/: app_ble.c ibeacon_service.c
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c hw_lpm.c hw_timerserver.c hw_uart.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c ibeacon_service.c eddystone_tlm_service.c eddystone_uid_service.c eddystone_url_service.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_ipcc.c stm32wbxx_hal_gpio.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_if.c tl_mbox.c hci_tl.c shci_tl.c
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c lpm.c otp.c scheduler.c stm_list.c stm_queue.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/Src/core/: osal.c ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/Src/blesvc/: svc_ctl.c
